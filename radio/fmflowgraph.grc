options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: 99.5e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 98.7e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '800000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: BlackHole 16ch
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {state: bypassed}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: channel_freq + 8e5
    gain0: '7'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: channel_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
